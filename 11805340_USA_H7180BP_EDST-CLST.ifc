Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-11-11T08:36:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 11 08:36:39 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{9681B163-0153-4145-A2B5-596F16C1B297}\ifc * Database version: 5507 * Database creation date: Thu Nov 11 08:36:38 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 11 08:36:38 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 11 08:36:38 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 22718045_USA_11805340_H7180BP_EDST-CLST, 11805340_USA_H7180BP_EDST-CLST:22718045_USA_11805340_H7180BP_EDST-CLST:206801
In: Level 1
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, z_Miele_Design_OBSW, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - Reference: 22718045_USA_11805340_H7180BP_EDST-CLST
Pset_ManufacturerTypeInformation - Manufacturer: Miele
